DHCPCD_INTERFACE_INC_WRLINUX = ""
DHCPCD_INTERFACE_INC_WRLINUX_osv-wrlinux = "dhcpcd_interface_wrlinux.inc"
require ${DHCPCD_INTERFACE_INC_WRLINUX}
